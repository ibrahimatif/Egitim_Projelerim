org 0000h
sjmp BASLA
ORG 000Bh
SJMP ZAMANLAYICI
org 0030h
	BASLA:
	JNB P1.0, TIMER
	MOV P2,#00h
	MOV A,#00h
	CLR P1.7
	SJMP BASLA
	
	TIMER:
	JNZ YAK
	SETB EA
	SETB ET0
	SETB TR0
	MOV TH0,#0F0h
	MOV TMOD,#01h
	MOV R7,#0Fh
	MOV A,#01h
	
	YAK:
	MOV P2,#00h	
	MOV P0,#00h
	MOV P2,#88h
	MOV P2,#88h
	MOV P2,#00h
	MOV P0,#01h
	MOV P2,#3Eh
	MOV P2,#3Eh
	MOV P2,#00h
	MOV P0,#02h
	MOV P2,#0AEh
	MOV P2,#0AEh
	MOV P2,#00h
	MOV P0,#03h
	MOV P2,#38h
	SJMP basla
	ZAMANLAYICI:
	CLR TF0
	DJNZ R7,PORTTERS
	MOV A,#00h
	CPL P1.7
	RETI
	PORTTERS:
	RETI
	CPL P1.7
	
	
	END